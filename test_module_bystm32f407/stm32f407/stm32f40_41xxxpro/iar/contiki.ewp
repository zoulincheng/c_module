# IAR project contiki.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F40XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\user; ..\contiki\core; ..\contiki\cpu\stm32f407; ..\FWLIB\inc; ..\cmsis\Include; ..\cmsis\STM32F4xx\Include; ..\contiki\platform\stm32f407; ..\utility; ..\xprintf; ..\contiki\apps\shell; ..\lv_mem; ..\qmemmang; ..\tlsf; ..\umm_malloc; ..\message_queue
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: contiki.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../apptest/: app_test_lv_mem.c apptest_qmem.c apptest_tlsf.c apptest_ummollc.c
  group contiki/apps/serila-shell
    ../contiki/apps/serial-shell/: serial-shell.c
  group contiki/apps/shell
    ../contiki/apps/shell/: shell.c
  group contiki/core/dev
    ../contiki/core/dev/: serial-line.c
  group contiki/core/lib
    ../contiki/core/lib/: crc16.c list.c me_tabs.c memb.c mmem.c random.c ringbuf.c ringbufindex.c
  group contiki/core/sys
    ../contiki/core/sys/: ctimer.c etimer.c process.c procinit.c stimer.c timer.c
  group contiki/cpu
    ../contiki/cpu/stm32f407/: arch_can.c arch_io.h board.c cantest.c clock.c dbg_uart.c stm32f407_uart.c uart.c
  group lv_mem
    ../lv_mem/: lv_log.c lv_mem.c
  group message_queue
    ../message_queue/: message_queue.c
  group qmemmang
    ../qmemmang/: qmemmang.c
  group start
    ../cmsis/STM32F4xx/src/iar/: startup_stm32f40_41xxx.s
  group stlib
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group tlsf
    ../tlsf/: tlsf.c
  group umm_malloc
    ../umm_malloc/: umm_info.c umm_integrity.c umm_malloc.c umm_poison.c
  group user
    ../user/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group utility
    ../utility/: common.c sysprintf.c utility.c
  group xprintf
    ../xprintf/: xprintf.c
